# Autodesk Inventor assembly: 21.1838 CHAIN PULLEY 45 A
## iProperties
Created: 2007-05
Part Number: 21.1838 CHAIN PULLEY 45 A
Document SubType Name: Assembly
Designer: Andy Moles
Author: Andy Moles
